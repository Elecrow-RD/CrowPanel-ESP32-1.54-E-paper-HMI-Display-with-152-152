# Repository Elecrow-RD/CrowPanel-ESP32-1.54-E-paper-HMI-Display-with-152-152

File readme.md:

### 1, Product picture

### 2, Product version number

|      | Hardware | Software | Remark |
| ---- | -------- | -------- | ------ |
| 1    | V1.0     | V1.0     | latest |

### 3, product information

#### Display Module Specifications

- Size: 1.54 inch
- MCU: ESP32-S3, up to 240 MHz
- Flash: 8 MB
- PSRAM: 8 MB
- Material: Active Matrix Electrophoretic Display (AM EPD)
- Driver Chip: SSD1680
- Resolution: 128(H)*296(V) Pixel
- Pixel pitch: 0.227*0.226
- Viewing Angle: Full Viewing Angle
- Communication interface: 3-/4-wire SPI
- Interface: UART0 x1, BAT x1
- Button: Dial Switch x1, Menu Button x1, Back Button x1, REST Button x1, BOOT Button x1
- Development Environment: Arduino IDE、ESP IDF、MicroPython
- Display Color: Black and white
- Refresh Mode: Partial refresh (saves more power)
- Display Operation Voltage: 2.2~3.7V
- Acrylic Case: White Acrylic Case
- Operation Temperature: -0~50℃
- Storage Temperature: -25~70℃
- Active Area: 37.18(H)\*48.32(L) (H*L)

### 4, Use the driver module

| Name    | dependency library     |
| ------- | ---------------------- |
| SSD1680 | EPD<br />version=1.0.0 |

### 5,Quick Start

##### Arduino IDE starts

1.Download the library files used by this product to the 'libraries' folder.

C:\Users\Documents\Arduino\libraries\

2.Open the Arduino IDE

3.Open the code configuration environment and burn it

### 6,Folder structure.

|--3D file： Contains 3D model files (.stp) for the hardware. These files can be used for visualization, enclosure design, or integration into CAD software.

|--Datasheet: Includes datasheets for components used in the project, providing detailed specifications, electrical characteristics, and pin configurations.

|--Eagle_SCH&PCB: Contains **Eagle CAD** schematic (`.sch`) and PCB layout (`.brd`) files. These are used for circuit design and PCB manufacturing.

|--example: Provides example code and projects to demonstrate how to use the hardware and libraries. These examples help users get started quickly.

|--factory_firmware: Stores pre-compiled factory firmware that can be directly flashed onto the device. This ensures the device runs the default functionality.

|--factory_sourcecode: Contains the source code for the factory firmware, allowing users to modify and rebuild the firmware as needed.

### 7,Pin definition

#define SCK 12

#define MOSI 11

#define RES 10

#define DC 13

#define CS 14

#define BUSY 9

## EAGLE design Eagle_SCH&PCB/CrowPanel ESP32 Display-1.54(E) Inch(1).brd

Parts:
ANT1: ADAFRUIT_ANTENNA; ADAFRUIT_RN-ANT
B1: BAT-1.0MM-W; SH1.0MM-W
C2: 4.7uF; 0402
C3: 10nF; 0402
C4, C5, C9: 10uF; 0402
C7, C8: 22uF; 0603
C10: 100nF; 0402
C14, C42: 1uF; 0402
C20, C21, C22, C23, C24, C25, C26, C27, C28, C29: 1uF/25V; 0402
C36, C37, C40, C41, C46, C47: 0.1uF; 0402
C38, C39: NC; 0402
C44, C45: 12pF; 0402
D1: RED; A_XBJ_DISCRETE_LED-0603
D2, D3, D7, D8, D9, D10, D11: B5819WS; DISCRETE_SOD323
D4, D5, D6: MBR0530WS; DISCRETE_SOD323
J2: WZ3532R024-ESP32-V0.1-20221226_USB_TYPE-C_16PIN3.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; WZ3532R024-ESP32-V0.1-20221226_KEVIN_3.0TYPEC-SMD
K1, K2: KEY4.5; KEY-4.5
K3, K4: KEY_363.5; KEY_3*6*3.5
K5: TM_2024A
L1: 4.7uH/1.6A; A9G_DISCRETE_L0805
L2: FNR4012S470MT
L3: 0R; L0402
L4: 2nH/900mA; L0402
P2: 1X4_CONN1X4_XH2.54_SMD; CONN-SMD-4P-P2.54
P3, P4, P5, P6, P7, P8, P9, P32, P33, P34, P35, P36, P37, P42, P48, P50, P51, P52, P53, P54, P55, P56, P57, P58: CROWPI_POW_PADPAD-1.0MM; CROWPI_POW_PAD-1.0MM
Q1, Q2, Q3, Q7, Q8: 2N7002W; SOT-323_W
Q4: Si1308EDL; SOT-323_W
R1, R4: 5.1K; 0402
R2, R3: 22R; 0402
R5, R27, R28, R29, R30, R31: 4.7K; 0402
R6: NC; 0402
R7, R8, R14, R23: 10K; 0402
R9, R15, R16, R17, R32, R33, R34, R35: 5.6K; 0402
R10, R11, R44: 0R; 0402
R12: 3K; 0402
R13: 45.3K; 0402
R18: 100K; 0402
R24: 2.2R; 0402
R43: 499R; 0402
U1: W25Q64JVXGIQ; XSON-EP(4×4)
U2: RY3420; CROWBOT_-V1.0-20220525_A_XBJ_SOT23-5
U3: 0.5_FPC_24P
U4: CH340K; ESOP-10-EP-150MIL
U5: UMH3NTN; SOP65P210X100-6N
U6: DFN8_4054A; DFN8_SOP23-5
U7: ESP32-S3; QFN56-7*7MM
U8, U9: HXY2101EI-PMOS/1.8A; SOT-323_W
X1: 40MHz(10ppm); ADAFRUIT_NX3225

Connections:
3V3: C8.2, C9.2, C14.2, C22.1, C24.1, C36.2, C40.2, C46.2, C47.2, L1.2, L2.1, L4.1, P9.P$1, P48.P$1, Q1.1 (G), Q2.1 (G), Q7.1 (G), Q8.1 (G), R6.2, R9.2, R13.2, R15.2, R23.2, R27.2, R28.2, R29.2, R30.2, R31.1, R32.2, R33.2, U3.15 (VDDIO), U3.16 (VCI), U7.20 (VDD3P3_RTC), U7.46 (VDD3P3_CPU), U7.55 (VDDA), U7.56 (VDDA)
3V3_RX: Q2.2 (S), Q8.2 (S), R9.1, R32.1, U7.50 (U0RXD)
3V3_TX: Q1.2 (S), Q7.2 (S), R15.1, R33.1, R43.1
5V: D7.+ (A), D8.+ (A), P2.2, P34.P$1, R16.2, R17.2, U8.3 (D)
5V_RX: Q7.3 (D), R2.2, R34.1
5V_RX0: P2.4, P32.P$1, Q2.3 (D), R17.1
5V_TX: Q8.3 (D), R3.2, R35.1
5V_TX0: P2.3, P33.P$1, Q1.3 (D), R16.1
BAT: B1.1 (B+), C5.2, D3.+ (A), D11.+ (A), P7.P$1, U6.3 (BAT), U9.3 (D)
BOOT: K1.2, U5.3 (C2), U7.5 (GPIO0)
D+: J2.A6 (DP1), J2.B6 (DP2), R11.1
D-: J2.A7 (DN1), J2.B7 (DN2), R10.1
DTR: R7.1, U4.4 (DTR#), U5.4 (E2)
EN_RESET: C2.2, K2.2, R23.1, U5.6 (C1), U7.4 (CHIP_PU)
GDR: P36.P$1, Q4.1 (G), U3.2 (GDR)
GND: ANT1.GND, B1.2 (B-), B1.3, B1.4, C2.1, C3.1, C4.1, C5.1, C7.1, C8.1, C9.1, C10.2, C14.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C44.1, C45.2, C46.1, C47.1, D1.-, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.P$6, J2.P$7, J2.P$8, J2.P$9, K1.1, K2.1, K3.2, K4.1, K5.3, K5.5, K5.6, K5.7, K5.8, P2.1, P2.5, P2.6, P3.P$1, P8.P$1, P35.P$1, Q3.2 (S), R1.1, R4.2, R12.1, R14.1, U1.4 (GND), U1.9 (EP), U2.2 (GND), U3.25, U3.26, U4.3 (GND), U4.EP, U6.2 (GND), U7.57 (GND), X1.2 (G2), X1.4 (G1)
IO1_EXIT: K4.2, R28.1, U7.6 (GPIO1)
IO2_MENU: K3.1, R27.1, U7.7 (GPIO2)
IO3: U7.8 (GPIO3)
IO4_DOWN: K5.1, R30.1, U7.9 (GPIO4)
IO5_CONF: K5.4, R31.2, U7.10 (GPIO5)
IO6_UP: K5.2, R29.1, U7.11 (GPIO6)
IO7_LCD_3.3_CTL: R18.1, U7.12 (GPIO7)
IO8: U7.13 (GPIO8)
IO9_BUSY: P50.P$1, U3.9 (BUSY), U7.14 (GPIO9)
IO10_RES: P51.P$1, U3.10 (RES), U7.15 (GPIO10)
IO11_SPI_MOSI: P55.P$1, U3.14 (SDA), U7.16 (GPIO11)
IO12_SPI_CLK: P54.P$1, U3.13 (SCL), U7.17 (GPIO12)
IO13_D/C: P52.P$1, U3.11 (D/C), U7.18 (GPIO13)
IO14_CS: P53.P$1, U3.12 (CS), U7.19 (GPIO14)
IO15: U7.21 (XTAL_32K_P)
IO16: U7.22 (XTAL_32K_N)
IO17_U1TXD: U7.23 (GPIO17)
IO18_U1RXD: U7.24 (GPIO18)
IO19_LED: R5.2, U7.25 (GPIO19)
IO20: U7.26 (GPIO20)
IO21: U7.27 (GPIO21)
IO38: U7.43 (GPIO38)
IO39: U7.44 (MTCK)
IO40: U7.45 (MTDO)
IO41: U7.47 (MTDI)
IO42: U7.48 (MTMS)
IO45: U7.51 (GPIO45)
IO46: U7.52 (GPIO46)
IO47: U7.37 (SPICLK_P)
IO48: U7.36 (SPICLK_N)
LCD_GND: C20.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, D5.- (C), P42.P$1, Q3.3 (D), R24.1, U3.6 (TSCL), U3.7 (TSDA), U3.8 (BS), U3.17 (VSS)
unnamed: R7.2, U5.2 (B1)
unnamed: D10.- (C), D11.- (C), U8.1 (G)
unnamed: R8.2, U5.5 (B2)
unnamed: J2.A5 (CC1), R1.2
unnamed: D8.- (C), D9.- (C), U9.1 (G)
unnamed: Q3.1 (G), R18.2
unnamed: R3.1, U4.8 (TXD)
unnamed: R13.1, R14.2, U2.5 (FB)
unnamed: C3.2, U4.10 (V3)
unnamed: L1.1, U2.3 (SW)
unnamed: J2.B5 (CC2), R4.1
unnamed: R12.2, U6.5 (PROG)
unnamed: D1.+, R5.1, R6.1
unnamed: ANT1.1 (FEED), C38.2, L3.1
unnamed: C39.2, L3.2, U7.1 (LNA_IN)
unnamed: C37.2, L4.2, U7.2 (VDD3P3), U7.3 (VDD3P3)
unnamed: R2.1, U4.9 (RXD)
unnamed: R44.2, U7.54 (XTAL_P)
unnamed: C21.1, D4.- (C), D5.+ (A)
unnamed: C21.2, D6.+ (A), L2.2, Q4.3 (D)
unnamed: R43.2, U7.49 (U0TXD)
unnamed: C44.2, U7.53 (XTAL_N), X1.1 (X1)
unnamed: C45.1, R44.1, X1.3 (X2)
PREVGH: C29.1, D6.- (C), P56.P$1, U3.21 (PREVGH)
PREVGL: C20.1, D4.+ (A), P57.P$1, U3.23 (PREVGL)
RESE: P37.P$1, Q4.2 (S), R24.2, U3.3 (RESE)
RTS: R8.1, U4.6 (RTS#), U5.1 (E1)
SPICLK: U1.6 (CLK), U7.33 (SPICLK)
SPICS0: U1.1 (/CS), U7.32 (SPICS0)
SPID: U1.5 (DI(IO0)), U7.35 (SPID)
SPIHD: U1.7 (/HOLD/RESET(IO3)), U7.30 (SPIHD)
SPIQ: U1.2 (DO(IO1)), U7.34 (SPIQ)
SPIWP: U1.3 (/WP(IO2)), U7.31 (SPIWP)
USB_D+: P6.P$1, R11.2, U4.1 (UD+)
USB_D-: P5.P$1, R10.2, U4.2 (UD-)
VBUS: C4.2, C10.1, D2.+ (A), D9.+ (A), D10.+ (A), J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), P4.P$1, R34.2, R35.2, U4.7 (VCC), U6.4 (VCC)
VCOM: C28.1, U3.24 (VCOM)
VDD: C25.1, U3.18 (VDD)
VDD_SPI: C41.2, C42.2, U1.8 (VCC), U7.29 (VDD_SPI)
VDHR: C23.1, P58.P$1, U3.5 (VDHR)
VIN: C7.2, D2.- (C), D3.- (C), D7.- (C), U2.1 (EN), U2.4 (VIN), U8.2 (S), U9.2 (S)
VSH: C26.1, U3.20 (VSH)
VSL: C27.1, U3.22 (VSL)

Notes on the sheet:
USB type-c座子
USB转串口
EXIT键 主页键
主控 ESP32-S3R8
EPD屏接口
拨轮开关
系统3.3V电源
电池及控制电路
BOOT
RESET
UART0电平转换
LCD使能
500mA
IO45/IO46: pulldown!!!
IO43
IO44
UART1
POWER LED
外接UART0电平转换

Board: 2 copper layers, 48.3 x 31.8 mm, 126 parts (24 on the bottom side), 73 nets.

Other parts of the board:
U$6: LOGO-MIN
